require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "24f39d5c44341d35b2056be3b53bb828"
SRC_URI[sha256sum] = "d184bb74758d4ac69826823934cda1d46e81402fc16ebdb2ecacdc1a8fe0b568"

