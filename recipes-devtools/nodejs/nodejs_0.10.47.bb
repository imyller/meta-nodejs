require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "ba6c57fdcaeb2f5d418ddce376c69ecc"
SRC_URI[sha256sum] = "5281fa7ddff755c34602a09ef8027f0bda0f7851b1e374fd0e0c33da93123056"
