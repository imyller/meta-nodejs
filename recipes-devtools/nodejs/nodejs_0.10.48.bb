require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "6646738d664ca4908ad0f288498c2334"
SRC_URI[sha256sum] = "27a1765b86bf4ec9833e2f89e8421ba4bc01a326b883f125de2f0b3494bd5549"
