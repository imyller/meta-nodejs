require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=14115ff11211df04b031ec7d40b6d31b"

SRC_URI[md5sum] = "b78430ef07c09381f5f4b38359156cc8"
SRC_URI[sha256sum] = "ddea5e253812f167608fbdda6ff29ffc30dc6f669cf2f6e4249938d28b9cd44d"
