require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e1a7c7ec8f4bb13489af7a6110a6083d"

SRC_URI[md5sum] = "1292af0584de9ba773eb06120b5ddb86"
SRC_URI[sha256sum] = "6b48461dff7a002cedba45a016af81f66a79b465cee1d7bfe5bd74910c1a7bfa"
