require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=96aa1ac122c41f8c08a0683d4b2126b5"

SRC_URI[src.md5sum] = "a7cc707ccf2ec436a854f5d6b00c2ce2"
SRC_URI[src.sha256sum] = "45eab3d415616e5831ba5961b67cec5423e1f9c175ca7e331de7f560c2998d9f"
