require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=8e3c01094f0fcb889b13f0354e52f914"

SRC_URI[src.md5sum] = "410330eb0705b23ac03d9ff1bc12592b"
SRC_URI[src.sha256sum] = "cbe1c6e421969dd5639d0fbaa6d3c1f56c0463b87efe75be8594638da4d8fc4f"
