require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=8e3c01094f0fcb889b13f0354e52f914"

SRC_URI[src.md5sum] = "1885586b4b8a2263f77dce27855661e9"
SRC_URI[src.sha256sum] = "74ced83b8d890d90e2a8b0d54b0d0e9b5e01d6fd6148cec6e9911ff6eaf0cf21"
