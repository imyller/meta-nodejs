require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=8e3c01094f0fcb889b13f0354e52f914"

SRC_URI[src.md5sum] = "da43ffb5d05f2488cce379300e80656b"
SRC_URI[src.sha256sum] = "0838f12e329edb252e6e6baddca85632bf5ff2ec900e737e88f9bf9b38946b1b"
