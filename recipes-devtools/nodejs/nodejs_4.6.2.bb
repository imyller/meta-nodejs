require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "b0a4cbcab172665db27ba6d744e24ac1"
SRC_URI[src.sha256sum] = "3c8f3af398c348cdf90fef9b983e4b46aae96a56238236542925e0bb4ee27ee8"
