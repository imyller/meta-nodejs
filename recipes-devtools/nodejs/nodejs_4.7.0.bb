require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "86055a29ba9dbfec2e2cfe95afaa6c58"
SRC_URI[src.sha256sum] = "0bc45fc02e425746001a8f012d6781fa5da6e629a43654c84ab7e767368fec61"
