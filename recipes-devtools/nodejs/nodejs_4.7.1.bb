require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "635d932ea96b3150771fffab23ad8278"
SRC_URI[src.sha256sum] = "9c0472b8faf03758b6ff86e4a05d03e399b94b6b83c6c0847e5eaedb448a1c49"
