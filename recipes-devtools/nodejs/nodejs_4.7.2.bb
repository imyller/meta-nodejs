require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "54c1aada3ef87fb8286f7f0e3a9da94e"
SRC_URI[src.sha256sum] = "771e9f4ef946f8f13452039c5bd1eb3edb9e4a0937b7a5f328dbd8e529a09284"
