require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "12b75c2bc298b6b4cf464a6f0c0f5087"
SRC_URI[src.sha256sum] = "1549d4e0aeb9419ddb85ba4dffdba8d0e2f9a9b904e80765b044c4f7d9f485ed"
