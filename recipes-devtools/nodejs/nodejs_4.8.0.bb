require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "9a94dcf14b35af569435aac1f8b9bba5"
SRC_URI[src.sha256sum] = "6e65d19e0135be474df53a350af766a8f1ba5ef1a5288a4da993a1a9b0e04942"
