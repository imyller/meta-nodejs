require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "8a66d0eb189d911b308226a208e2f8c5"
SRC_URI[src.sha256sum] = "0cdc67fb2df091414447e2e1750b371be99a7b61c11ade0261ce5bab845e9dd1"
