require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "9de1bcd210de5bd2d93a1070a775162c"
SRC_URI[src.sha256sum] = "29dc51947b09f081263bf60f70525979e3f78efc21c68f108bc3c6c64d18b904"
