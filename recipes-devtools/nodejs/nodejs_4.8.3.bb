require nodejs_4.inc
require nodejs_iojs.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=f45e9ffb97e64da46d14f462d34a039f"

SRC_URI[src.md5sum] = "92dd08a78c40a485f5f60d2bca3b92b8"
SRC_URI[src.sha256sum] = "f8a5b7fe246f8358121e057f26411d3be9657a328b146d74abf483a956702868"
