require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ff28f0c5e93eb4e48a07fdfca061b006"

SRC_URI[src.md5sum] = "bc11529cde4757a640f43642609fb6a5"
SRC_URI[src.sha256sum] = "be1211ce415ecc48412ce3e9d5b48cf9ec8e99b34f25b4e1909a02679cc72fab"
