require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ff28f0c5e93eb4e48a07fdfca061b006"

SRC_URI[src.md5sum] = "90ed323517bce8cabbd70ef4d558139a"
SRC_URI[src.sha256sum] = "250c12a561d7319e71e142ee92ab682494c7823d81ce24703c80eb52bdf9ba42"
