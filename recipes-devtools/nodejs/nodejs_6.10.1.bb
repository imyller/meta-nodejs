require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "9078d08b2716abc02fdc3e29dda29fe2"
SRC_URI[src.sha256sum] = "2c7a643b199c63390f4e33359e82f1449b84ec94d647c606fc0f1d1a2b5bdedd"
