require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "69b224d2a21ae8845e3bea412cd79faf"
SRC_URI[src.sha256sum] = "9b897dd6604d50ae5fff25fd14b1c4035462d0598735799e0cfb4f17cb6e0d19"
