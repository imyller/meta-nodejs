require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "73982a158e4f05d36c01b7a97e38da18"
SRC_URI[src.sha256sum] = "a8f679f595fd921305c28d126935ad59b4419ac8474a99997a31e01ab50acd3d"
