require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ff28f0c5e93eb4e48a07fdfca061b006"

SRC_URI[src.md5sum] = "c327fe11c295485326940ff1b2740943"
SRC_URI[src.sha256sum] = "fa26d4380150fbb69a48bddaec6143e176effe043cfe44e512c5ef9d22618b63"
