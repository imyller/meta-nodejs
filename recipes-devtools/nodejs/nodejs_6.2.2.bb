require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3c200f3c2be8e417b439aaf7a964ab95"

SRC_URI[src.md5sum] = "1120e8bf191fdaee42206d031935210d"
SRC_URI[src.sha256sum] = "b6baee57a0ede496c7c7765001f7495ad74c8dfe8c34f1a6fb2cd5d8d526ffce"
