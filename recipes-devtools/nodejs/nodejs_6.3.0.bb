require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3c200f3c2be8e417b439aaf7a964ab95"

SRC_URI[src.md5sum] = "8c14e5c89d66d4d060c91b3ba15dfd31"
SRC_URI[src.sha256sum] = "4ed7a99985f8afee337cc22d5fef61b495ab4238dfff3750ac9019e87fc6aae6"
