require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=3c200f3c2be8e417b439aaf7a964ab95"

SRC_URI[src.md5sum] = "6a08fbe8788ea4c798ada16e274d8d98"
SRC_URI[src.sha256sum] = "3f6144dcf13c210b11c83dc0b0a841219347a769b5a3b883b20f7ab8dc4008f6"
