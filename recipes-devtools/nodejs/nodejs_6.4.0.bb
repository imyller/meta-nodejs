require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "16d5fe2edee12178b38839a4a5f389e9"
SRC_URI[src.sha256sum] = "a58c930618cf5b0862aa329a626e850519036acfcd746983010c9946df1797d0"
