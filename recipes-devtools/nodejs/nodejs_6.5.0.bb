require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "43a0949a027b2eea92632f95600c21fb"
SRC_URI[src.sha256sum] = "d7742558bb3331e41510d6e6f1f7b13c0527aecc00a63c3e05fcfd44427ff778"
