require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "91d9a60ffdfec6287d220a25b99b8e31"
SRC_URI[src.sha256sum] = "11b957de855a392ceaa8b300ec66236d6f9c6baa184837d00bdaba2da4aefe91"
