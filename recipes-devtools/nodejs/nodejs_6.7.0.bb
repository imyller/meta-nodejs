require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "a42b7ab2bcf5f8d94a432163d90f3026"
SRC_URI[src.sha256sum] = "02b8ee1719a11b9ab22bef9279519efaaf31dd0d39cba4c3a1176ccda400b8d6"
