require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "3bddf030853a2444b4ef3b67cc6f538b"
SRC_URI[src.sha256sum] = "a8a2d4b74734991dd45e5b2b0b13617864f1283f6d6bc262e1e4d30741114352"
