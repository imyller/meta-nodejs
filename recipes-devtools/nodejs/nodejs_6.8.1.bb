require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "fbca47ffd005c0d8923dfc22523773ba"
SRC_URI[src.sha256sum] = "736f7651f59a78d5a0d88ab2430c93fc29a8efd1c06fd3fb4eb915b262bc2769"
