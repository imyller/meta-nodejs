require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r2"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "0d3117846c6704b36108fcdbf30e03c1"
SRC_URI[src.sha256sum] = "a98997ca3a4d10751f0ebe97839b2308a31ae884b4203cda0c99cf36bc7fe3bf"
