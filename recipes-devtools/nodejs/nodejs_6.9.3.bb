require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "f834f195c5fe7caea8d3989315519ceb"
SRC_URI[src.sha256sum] = "74b3a5c5419c674598376eefd435f472e9a36a3c27029b5fa64ba3037ed08fc9"
