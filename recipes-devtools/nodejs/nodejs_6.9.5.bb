require nodejs_6.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=19eb7a3bddc44523bf96176c3da4b422"

SRC_URI[src.md5sum] = "a2a820b797fb69ffb259b479c7f5df32"
SRC_URI[src.sha256sum] = "f7e9ab702c5d1f5a3521199c04cc670fda3cf4b0e48548b09ac7ac874ccb504a"
