require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "1db5df2cb025f9c70e83d9cf21c4266a"
SRC_URI[src.sha256sum] = "595e7e2a37d1e0573044a90077bb12c0f750e5d8851899ffa74038238da9a983"
