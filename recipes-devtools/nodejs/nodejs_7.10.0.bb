require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "3c8c8f61a898c3c7292ff58a4e27fa33"
SRC_URI[src.sha256sum] = "c4843fe8bffb59c2327063a5e67a89af60d7927f7ace7548695a2cf4c1aa6d03"

