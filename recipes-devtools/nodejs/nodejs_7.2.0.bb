require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "ea2dd2de3e93b601f576bf24c1ab56ec"
SRC_URI[src.sha256sum] = "c3f53a5d8cea145e25706bb21cdac62f1b3314db35785bcf468558a29cfc352f"
