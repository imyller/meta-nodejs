require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "20167fa2b3ef3e17430af4fae9a26427"
SRC_URI[src.sha256sum] = "fd08b8ba43b0596a7160b09a37113ac03b4b0976ec7e48980b7b8c078aa51b02"
