require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "16f516a8433cd1d87ea8898b090432e7"
SRC_URI[src.sha256sum] = "5ba8a26e5341ec738ee6f1aacdd82be4002aef64716d069e060d901ade13c5b0"
