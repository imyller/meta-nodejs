require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "9732aba61759bc97d2bb2e7d82453f83"
SRC_URI[src.sha256sum] = "69b76c86e6fc9914fa136089d8c28a4828c14aa8792cbdf946090a5a2afd25b6"
