require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=41a3a0ccf7f515cac3377389dd8faac8"

SRC_URI[src.md5sum] = "8b648e7f83ec6f1aa52b3e3b87999761"
SRC_URI[src.sha256sum] = "0da8e0288b5c0f136e650b7119219968720caf88b5a67ef0591555113f0844c2"
