require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "3de98b48d1836155aed0bf50503b97fb"
SRC_URI[src.sha256sum] = "809e80265e332fe1a8268e5a73eb219c356810fe86c69fd2d931c52e07211970"
