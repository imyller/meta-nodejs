require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "5714e2c9b25b9eb4d893ba270106084d"
SRC_URI[src.sha256sum] = "6716b933ff69f23399e743fd34e08352cd265e559caec5f06ee04b9222721efe"
