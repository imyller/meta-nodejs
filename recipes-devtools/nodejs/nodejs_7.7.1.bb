require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "559b29d57a5ad2bc04129d5f39b3ce5b"
SRC_URI[src.sha256sum] = "9e87ec5420d558ca9651d13b10dd4a1be954fea0fc7a909016a1cc4aedfa651c"
