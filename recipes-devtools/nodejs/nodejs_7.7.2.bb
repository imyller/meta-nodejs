require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "a4a1f7c1a72512e1d61377814d41675a"
SRC_URI[src.sha256sum] = "a6a1041337bae3e3b5645316672cd3b3867fdfc569f561aec824c0ea622fff9c"
