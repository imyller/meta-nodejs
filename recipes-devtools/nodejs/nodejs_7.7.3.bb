require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "c0a3e0f47ed5f936e2bf38cac45ba754"
SRC_URI[src.sha256sum] = "81edeed9e3daa34a8962339357e2b9c5f7d9248e025ec872b6a55a519d3589b9"
