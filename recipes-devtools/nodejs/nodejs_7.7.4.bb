require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "056ae057494de56828f02693a7b13164"
SRC_URI[src.sha256sum] = "d76bad6e843005aa016f285e983493e344fde80eac4258b4bf9ee8654f5d6e43"
