require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "0c725bfe5663d99d69410437487cf11f"
SRC_URI[src.sha256sum] = "6aa2ab52763f33ce09b63e913f3caf67d9d4b1120c70b087b50155bd647b76da"
