require nodejs_7.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=d29463feca32ea5977af7b6c7d62c14a"

SRC_URI[src.md5sum] = "60fb5fa8485881c2eaad09dfad8039d3"
SRC_URI[src.sha256sum] = "5cc131bb16f7ca688c29634a18b3c6a7816609a431a509f31baedf7caf25d626"
