require iojs1.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c3f0b9717b132a6dddcf86fa45498003"

SRC_URI[md5sum] = "a13aa682bdf03ff9d94d4caa9d0ce03b"
SRC_URI[sha256sum] = "59f4d34eafe70b1e96efba7491556db9ec449e5774352885a73ff41bad7c2965"
