require iojs1.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c3f0b9717b132a6dddcf86fa45498003"

SRC_URI[md5sum] = "b84a67db59f13dd53fe4edea20c1ed24"
SRC_URI[sha256sum] = "f0b8a8db1bf434eaebf4d6a7fcfd6adeaf85ab22f410f202b37a9c76781e7f7b"
