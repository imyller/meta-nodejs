require iojs1.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c3f0b9717b132a6dddcf86fa45498003"

SRC_URI[md5sum] = "6a52c79600fb28ed8c96bb0583333090"
SRC_URI[sha256sum] = "33666fce914ca57ef60e2e29d7b02cd64c99a8609287a9227da2087ab9c65d9d"
