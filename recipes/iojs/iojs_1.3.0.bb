require iojs.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=c3f0b9717b132a6dddcf86fa45498003"

SRC_URI[md5sum] = "b54349ed75a94ec6752702b3350237be"
SRC_URI[sha256sum] = "eb652fb854274e04b4a309b1b8cd4d5bb3eb45882e9442bacb129d247e9de021"

