require iojs.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=c3f0b9717b132a6dddcf86fa45498003"

SRC_URI[md5sum] = "5d819bb187344160d57563b2bfd0a850"
SRC_URI[sha256sum] = "da7bbb2ec8d0980ddbfca9d6de2ba5e9d5b57b41f6ef50140da746577fc98c34"
