require iojs.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "9d43a84cb0300a76fb7017bb66766b40"
SRC_URI[sha256sum] = "83fc43cff80ebbbcb670110037fb2999202b00398ad5c63c7e76a8080b6a3b8a"
