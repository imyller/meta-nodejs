require iojs1.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "b0aaeafd8f51b83cd5cf802b66915856"
SRC_URI[sha256sum] = "46e8a405392e6557b833f43229d19fc7d9bc8f9a6b7423cd6d667a60d36abd7d"
