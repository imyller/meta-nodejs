require iojs.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "dfe44e8353eba5bd1145fdd1aab471e8"
SRC_URI[sha256sum] = "ea537c47a46a15fdae0eab884a7c8f947905bd0cadc3b0d3ca4dbc51fe4afb5f"

