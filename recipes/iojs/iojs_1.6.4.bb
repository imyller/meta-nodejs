require iojs.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "552ddbeb6a03a6f13ca882f5ec4f54c4"
SRC_URI[sha256sum] = "875db123a05b3e0ebf2e7f6bb88c0d70275099bc970f61fbbfb79d42de71fbe3"

