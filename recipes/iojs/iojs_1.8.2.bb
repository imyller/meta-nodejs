require iojs1.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "db8b4a558b1b01ceef5253a890b6e5f0"
SRC_URI[sha256sum] = "ea36c96061aa2b74275dc2c71ea2ff0efca0358ef628efe76ea324afeeb0e4f7"

