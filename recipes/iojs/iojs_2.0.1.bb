require iojs2.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "67608151a26b9db4eaa00108da91b3cc"
SRC_URI[sha256sum] = "6d27e6f632a6835b944a60eec1162d35cb6c8c3d0a2caf3e9737bf1ab8b74f47"

