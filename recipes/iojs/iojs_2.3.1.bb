require iojs2.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "727890d5439660dacd304a856075c882"
SRC_URI[sha256sum] = "c2198e3a63fc204a4bcb11568ce9925a4985b87048222a0a7da1143f8f866aee"
