require iojs2.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "8dd8c0c6d933d77239cb14b154bdb0a9"
SRC_URI[sha256sum] = "0384ea20739124c27dc9b47b8079f0c75efb33c7011c45f02243e9a015f8cd89"
