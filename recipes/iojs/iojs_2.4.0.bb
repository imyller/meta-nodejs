require iojs2.inc

LICENSE = "MIT & BSD & Artistic-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0198b9c2e097efc6f853718558c550db"

SRC_URI[md5sum] = "c1a957e0e2b3c41f943c247feaddc6b3"
SRC_URI[sha256sum] = "1e2546fef303f7bb99c29297459e8debda2684e27ff535a746f57d82915d013d"

