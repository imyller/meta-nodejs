require iojs3.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6c54279cbd792731a692d52c6fb9833"

SRC_URI[md5sum] = "2c369fc56cfa59ddab687ae443197ae9"
SRC_URI[sha256sum] = "c31ffbbc8ba1e2aa3834efb2441b967bb309f1beeda6c7a7c9ce0cc9fa3a89ee"
