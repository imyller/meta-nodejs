require iojs3.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6c54279cbd792731a692d52c6fb9833"

SRC_URI[md5sum] = "4173fa4a75107f2568636d3568afff22"
SRC_URI[sha256sum] = "e84a649858e6f5c1458c0d5d7bf1952f78e93a26ea6bc519222e92e43e2fadde"
