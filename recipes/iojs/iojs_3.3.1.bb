require iojs3.inc

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a6c54279cbd792731a692d52c6fb9833"

SRC_URI[md5sum] = "25c14883bb4940e8cdb7e0bb632a77a5"
SRC_URI[sha256sum] = "b1ce0bb2ddb5d012bd9f22c787a4c74ce5d1546553086e40785be91489fee1d1"
