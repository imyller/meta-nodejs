require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=4a31e6c424761191227143b86f58a1ef"

SRC_URI[md5sum] = "87768be7065d2120e71619948ab4bb2d"
SRC_URI[sha256sum] = "abddc6441e0f208f6ed8a045e0293f713ea7f6dfb2d6a9a2024bf8b1b4617710"
