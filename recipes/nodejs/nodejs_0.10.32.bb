require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=4a31e6c424761191227143b86f58a1ef"

SRC_URI[md5sum] = "f5fd3a03948ec5d12b49fdc7c49a5cac"
SRC_URI[sha256sum] = "c2120d0e3d2d191654cb11dbc0a33a7216d53732173317681da9502be0030f10"
