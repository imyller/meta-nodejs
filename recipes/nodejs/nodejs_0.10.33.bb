require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=4a31e6c424761191227143b86f58a1ef"

SRC_URI[md5sum] = "626ca8a4f8fec4df49c78ed53d46f1f7"
SRC_URI[sha256sum] = "75dc26c33144e6d0dc91cb0d68aaf0570ed0a7e4b0c35f3a7a726b500edd081e"

