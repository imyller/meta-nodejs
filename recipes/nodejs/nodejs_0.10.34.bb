require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "1e95f7e08376861846b1004bccc51100"
SRC_URI[sha256sum] = "d7f8473b5849873039f7e62595e12dcdb78c8dffda317e1253b3123876bf3415"

