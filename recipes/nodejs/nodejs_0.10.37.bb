require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "8790c6bf20b80825d4208e86fa814569"
SRC_URI[sha256sum] = "a5afad14117bb194731e73b4b6635f36950e9476d3873638856cba8dbb4783a5"
