require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "3f45f994f1f02736576bf7bff1870897"
SRC_URI[sha256sum] = "513da8ed5e48abefdfab664f1cabc160238d314a0481148804aff8fc6552b78b"

