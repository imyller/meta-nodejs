require nodejs_0.10.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "ae3465dd3910b47d3ae8217bb6a369c9"
SRC_URI[sha256sum] = "ebc1d53698f80c5a7b0b948e1108d7858f93d2d9ebf4541c12688d85704de105"
