require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "2356f55d70a013d7952aad17c25cbcfe"
SRC_URI[sha256sum] = "c672452a61dd37cf2779bc158b65a5a22af343da19fec1cddf9bced382a2595a"
