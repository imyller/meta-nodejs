require nodejs_0.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=e804bf1e856481415099460bc54d9316"

SRC_URI[md5sum] = "39c35e40b9d64a63fadd80c1c3e54851"
SRC_URI[sha256sum] = "4155639d71e690cafd885f58a8be3bf97a93c28875212aac991923d3ee589be8"
