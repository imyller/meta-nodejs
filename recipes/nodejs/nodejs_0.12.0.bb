require nodejs_0.12.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=14115ff11211df04b031ec7d40b6d31b"

SRC_URI[md5sum] = "62c8d9c74c8f68193f60e4cba020eb48"
SRC_URI[sha256sum] = "9700e23af4e9b3643af48cef5f2ad20a1331ff531a12154eef2bfb0bb1682e32"
