require nodejs_0.12.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=14115ff11211df04b031ec7d40b6d31b"

SRC_URI[md5sum] = "9df36aa321e7abf9f19513f2d2c9fc47"
SRC_URI[sha256sum] = "edbd3710512ec7518a3de4cabf9bfee6d12f278eef2e4b53422c7b063f6b976d"
