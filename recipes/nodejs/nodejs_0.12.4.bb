require nodejs_0.12.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=14115ff11211df04b031ec7d40b6d31b"

SRC_URI[md5sum] = "c2b4deea212c0b7c2f86368c65fab312"
SRC_URI[sha256sum] = "3298d0997613a04ac64343e8316da134d04588132554ae402eb344e3369ec912"
