require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b51c7609f2f30be5f02b26b0f1e56e55"

SRC_URI[src.md5sum] = "2c1a6100084893c21e895e100b276af7"
SRC_URI[src.sha256sum] = "e110e5a066f3a6fe565ede7dd66f3727384b9b5c5fbf46f8db723d726e2f5900"

