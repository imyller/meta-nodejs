require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=48a6cd99f7ddc587ef4da244477452dd"

SRC_URI[src.md5sum] = "97b2a3ff97a18745a402ba9fdd5da33d"
SRC_URI[src.sha256sum] = "febec3703a3fea9b64c46100a7b6a4408250027aa8259a2a815fd2275d502c49"

