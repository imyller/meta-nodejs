require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ee90ba97d933fc8d56e97812b7dd62e9"

SRC_URI[src.md5sum] = "bd52ba3c80947a8e4a37f00f16f54dd5"
SRC_URI[src.sha256sum] = "94ea40efeb598fed6e1a78990b698da73275c49876ec551dc36e11513c99fb6b"
