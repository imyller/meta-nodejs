require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ee90ba97d933fc8d56e97812b7dd62e9"

SRC_URI[src.md5sum] = "41d2b9fb5220af3fd98dd70fb33a2a10"
SRC_URI[src.sha256sum] = "8861b9f4c3b4db380fcda19a710c0430c3d62d03ee176c64db63eef95a672663"
