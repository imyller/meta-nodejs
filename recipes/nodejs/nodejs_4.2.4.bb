require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=963ca39eebcb15ac618bc3006504ae3f"

SRC_URI[src.md5sum] = "86e4d0d8b626f6e60ca7bef02f2543d2"
SRC_URI[src.sha256sum] = "4ee244ffede7328d9fa24c3024787e71225b7abaac49fe2b30e68b27460c10ec"
