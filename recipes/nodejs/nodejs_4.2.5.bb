require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=963ca39eebcb15ac618bc3006504ae3f"

SRC_URI[src.md5sum] = "58541fa6402ea76494ef8b8068fd01b9"
SRC_URI[src.sha256sum] = "00162c5a8fcc5c35b27df26c49a83c7f4d52b1c963339a8a20401b81743f7fad"

