require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=963ca39eebcb15ac618bc3006504ae3f"

SRC_URI[src.md5sum] = "b1287c356e904954da7e0c6435ff9948"
SRC_URI[src.sha256sum] = "ea5e357db8817052b17496d607c719d809ed1383e8fcf7c8ffc5214e705aefdd"
