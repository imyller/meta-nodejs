require nodejs4.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=963ca39eebcb15ac618bc3006504ae3f"

SRC_URI[src.md5sum] = "1134e19fba49fe1d1dc0fb4e11a4ccbd"
SRC_URI[src.sha256sum] = "18504ac6d903cd061f60a29dafcda416a078112f3404d23a7901c41a8e9706b9"
