require nodejs4.inc
require nodejs_iojs.inc

INC_PR = "r2"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=003f16759ef967194d594a5ac6490401"

SRC_URI[src.md5sum] = "d4eaaa7c139f13fc0168d9b5fbe13a0b"
SRC_URI[src.sha256sum] = "61e2d58e861b6c9dbf0ac7624b718198cbd59b88a9de31a39a05de95a32eee73"
