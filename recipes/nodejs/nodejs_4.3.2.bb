require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=003f16759ef967194d594a5ac6490401"

SRC_URI[src.md5sum] = "f08960ee686899b80e8539815154f4b5"
SRC_URI[src.sha256sum] = "1f92f6d31f7292ce56db57d6703efccf3e6c945948f5901610cefa69e78d3498"
