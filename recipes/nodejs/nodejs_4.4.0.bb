require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b70c304f43f326ddbc3474ba2b685522"

SRC_URI[src.md5sum] = "4783dd4443e5a3a3421785f8a5cf5ea4"
SRC_URI[src.sha256sum] = "2cfc76292576d17a8f2434329221675972c96e5fd60cd694610f53134079f92e"
