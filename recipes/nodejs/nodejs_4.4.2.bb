require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=b70c304f43f326ddbc3474ba2b685522"

SRC_URI[src.md5sum] = "a0f91fa97aa837658c1eaf9a9b80c873"
SRC_URI[src.sha256sum] = "ae91cb0a31f87b5b13bb2665178845d99abf1037dc3636fa88f442b4a4c65297"
