require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=96aa1ac122c41f8c08a0683d4b2126b5"

SRC_URI[src.md5sum] = "0f7feafa6a98af58fcd934c043ced0d5"
SRC_URI[src.sha256sum] = "8e67b95721aab7bd721179da2fe5dd97f9acc1306c15c9712ee103bcd6381638"
