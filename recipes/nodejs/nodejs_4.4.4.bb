require nodejs_4.inc
require nodejs_iojs.inc
require nodejs_lts.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=96aa1ac122c41f8c08a0683d4b2126b5"

SRC_URI[src.md5sum] = "1a0f41618b8290a9e96a5dc5d53c7b9d"
SRC_URI[src.sha256sum] = "53c694c203ee18e7cd393612be08c61ed6ab8b2a165260984a99c014d1741414"
