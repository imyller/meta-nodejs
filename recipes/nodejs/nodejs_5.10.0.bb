require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "d327f09767d3046395bbb358bcae7783"
SRC_URI[src.sha256sum] = "8faeb9af5bde641b6e5dfae32bfa99253df2bccf59cf8a62162760026411762b"
