require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "1378c65a30b5ebcd3a2fc7384477379e"
SRC_URI[src.sha256sum] = "c6e278b612b53c240ddf85521403e55abfd8f0201d2f2c7e3d2c21383054aacd"
