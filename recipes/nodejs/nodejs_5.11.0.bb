require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ff28f0c5e93eb4e48a07fdfca061b006"

SRC_URI[src.md5sum] = "8d2d0930b4cbe21e0e9486287d539d10"
SRC_URI[src.sha256sum] = "ef41b01a9e49de5a5d160071166f911d0bc9ff6a0bd0e88ea4863df572d95e91"
