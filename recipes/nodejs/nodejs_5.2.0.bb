require nodejs5.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ee90ba97d933fc8d56e97812b7dd62e9"

SRC_URI[src.md5sum] = "a86fab6ad50ffe2ad8b34e1ff100322b"
SRC_URI[src.sha256sum] = "5df5682f9fdd8e747f652e0b09fed46478a1e3df159797852787a074b8787664"
