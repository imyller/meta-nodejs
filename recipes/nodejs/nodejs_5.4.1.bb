require nodejs5.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ee90ba97d933fc8d56e97812b7dd62e9"

SRC_URI[src.md5sum] = "50d217c708884bf67cb3383d171106c5"
SRC_URI[src.sha256sum] = "78455ef2e3dea06b7d13d393c36711009048a91e5de5892523ec4a9be5a55e0c"
