require nodejs5.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "6f7c2cec289a20bcd970240dd63c1395"
SRC_URI[src.sha256sum] = "3af2cc5e5970afc83e59f2065fea2e2df846a544a100cd3c0527f0db05bec27f"
