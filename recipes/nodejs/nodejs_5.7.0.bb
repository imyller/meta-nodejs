require nodejs5.inc

INC_PR = "r1"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "8ab282434c79bedcfd20c0b74f66e38e"
SRC_URI[src.sha256sum] = "2338b46a2f45fbb747089c66931f62555f25a5928511d3a43bbb3a39dcded2d8"
