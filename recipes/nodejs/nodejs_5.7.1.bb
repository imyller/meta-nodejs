require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "3cd7c01dedcfd41ad9e5a445dcaee3ad"
SRC_URI[src.sha256sum] = "ecd4956335c6b86f1b72fd203abd9a833717e6800edb12208d0e3ce625330198"
