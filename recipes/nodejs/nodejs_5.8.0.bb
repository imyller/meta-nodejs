require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "ee5c24aaeb37ad4cc2ddd96a65ab1f4b"
SRC_URI[src.sha256sum] = "e8cd580cec1c62053e6357633b9e46d49df1fd5b9fc5c804ca59ba80d722b898"
