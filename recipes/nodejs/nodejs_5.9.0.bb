require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "78b405dab1f42482e63054265321a175"
SRC_URI[src.sha256sum] = "e5175a66481fd9389ef74ef8e8c164d052f139664deffc9e79241d6234760f3e"
