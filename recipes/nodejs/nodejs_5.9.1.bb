require nodejs_5.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2009da64eb521ee8edafd1c7ab5d9847"

SRC_URI[src.md5sum] = "346c9325912271dc7614fe955c75c3a6"
SRC_URI[src.sha256sum] = "9bfa882ba832c526add1f939121c79d95b9c592785ec8afe043086a0c7a30c18"
