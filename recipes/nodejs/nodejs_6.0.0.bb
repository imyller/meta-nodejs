require nodejs_6.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=ff28f0c5e93eb4e48a07fdfca061b006"

SRC_URI[src.md5sum] = "3049ee729fb601aea31a2379085be007"
SRC_URI[src.sha256sum] = "6db56d81a4e07ff4017809ad4ee49a5256fad804cd8527f8724f8e149e3dfc32"
